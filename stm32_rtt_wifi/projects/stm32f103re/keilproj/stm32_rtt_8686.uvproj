# Keil uVision project stm32_rtt_8686.uvproj, settings and files
target stm32_rtt_8686 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_rtt_8686
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\include;..\applications;..\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32_StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group RT-Thread_Kernel
    ../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread_CM3
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Startup
    ../applications/: application.c main.c stm32f10x_it.c
  group Driver
    ../drivers/: board.c
  group LwIP
    ../../../components/net/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../components/net/lwip/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
    ../../../components/net/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../../components/net/lwip/src/arch/: sys_arch.c
